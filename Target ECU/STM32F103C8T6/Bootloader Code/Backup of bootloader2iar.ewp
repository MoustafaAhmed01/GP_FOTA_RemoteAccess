# IAR project Backup of bootloader2iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bootloader2iar.srec
  ILINK.IlinkOutputFile: bootloader2iar.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: bootloader.c bootloader.h cmsis_compiler.h cmsis_iccarm.h cmsis_version.h Common_Macros.h Compiler.h core_cm3.h cstartup_M.c Delay.c Delay.h Det.c Det.h Dio.c Dio.h Dio_Cfg.h Dio_PBcfg.c Dio_Regs.h main.c Platform_Types.h Port.c Port.h Port_Cfg.h Port_PBcfg.c Port_Regs.h Std_Types.h stm32f103c8t6_registers.h stm32f103xb.h stm32f1xx.h stm32f1xx_hal.c stm32f1xx_hal.h stm32f1xx_hal_conf.h stm32f1xx_hal_def.h stm32f1xx_hal_dma.c stm32f1xx_hal_dma.h stm32f1xx_hal_dma_ex.h stm32f1xx_hal_exti.c stm32f1xx_hal_exti.h stm32f1xx_hal_flash.c stm32f1xx_hal_flash.h stm32f1xx_hal_flash_ex.c stm32f1xx_hal_flash_ex.h stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio.h stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_gpio_ex.h stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc.h stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rcc_ex.h stm32f1xx_it.h sys_timer.c sys_timer.h System_Config.h UART.c UART.h UART_Regs.h watchdog.c watchdog.h
  group Legacy
    ./: stm32_hal_legacy.h
