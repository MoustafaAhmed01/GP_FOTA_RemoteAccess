# IAR project A9G.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: A9G.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: A9G.c A9G.h CAN.c CAN.h CAN_PBCFG.c CAN_Regs.h Common_Macros.h Compiler.h cstartup_M.c Delay.c Delay.h Det.c Det.h Dio.c Dio.h Dio_Cfg.h Dio_PBcfg.c Dio_Regs.h DMA.c DMA.h Dma_Cfg.h DMA_PBcfg.c DMA_Registers.h LCD.c LCD.h LPWAN.c LPWAN.h main.c Platform_Types.h PLL.c PLL.h Port.c Port.h Port_Cfg.h Port_PBcfg.c Port_Regs.h Std_Types.h stm32f103c8t6_registers.h sys_timer.c sys_timer.h sys_timerPBcfg.c System_Config.h UART.c UART.h UART2.c UART2.h UART_Regs.h
