# IAR project PCB_2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PCB_2.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: adc.c adc.h ADC_Cfg.h ADC_PBcfg.c ADC_REG.h Common_Macros.h Compiler.h cstartup_M.c dc_motor.c dc_motor.h Delay.c Delay.h Det.c Det.h Dio.c Dio.h Dio_Cfg.h Dio_PBcfg.c Dio_Regs.h DMA.c DMA.h Dma_Cfg.h DMA_PBcfg.c DMA_Registers.h Fan.c Fan.h GPT.c GPT.h LCD.c LCD.h LPWAN.c LPWAN.h main.c Platform_Types.h PLL.c PLL.h Port.c Port.h Port_Cfg.h Port_PBcfg.c Port_Regs.h potentiometer.c potentiometer.h servo_motor.c servo_motor.h Std_Types.h stm32f103c8t6_registers.h sys_timer.c sys_timer.h System_Config.h TIM8_PWM.c TIM8_PWM.h TIM8_Registers.h Timer_Cfg.h UART.c UART.h UART_Regs.h
